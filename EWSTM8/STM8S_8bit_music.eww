<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8S_8bit_music.ewp</path>
  </project>
  <batchBuild/>
</workspace>


